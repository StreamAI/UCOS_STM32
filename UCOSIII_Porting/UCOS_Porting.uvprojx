# Keil uVision project UCOS_Porting.uvprojx, settings and files
target UCOS_Porting (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UCOS_Porting +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\uCOSIII\Source;.\uCOSIII\Ports;.\uCOSIII\Config;.\uCOSIII\uC-CPU;.\uCOSIII\uC-LIB;.\uCOSIII\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: stm32f10x_it.c
  group UCOSIII_Source
    ./uCOSIII/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_Port
    ./uCOSIII/Ports/: os_cpu_a.s os_cpu_c.c
  group UCOSIII_Config
    ./uCOSIII/Config/: app.c os_app_hooks.c
  group UCOSIII_CPU
    ./uCOSIII/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group UCOSIII_LIB
    ./uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOSIII_BSP
    ./uCOSIII/BSP/: bsp.c
